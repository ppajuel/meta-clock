FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-4.9:"

SRC_URI += "file://0001-am335x-boneblack.dts-convert-to-BBG-Wireless-plus-cl.patch \
			file://defconfig"
