FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-systemd-add-autoroot-to-tty-terminals.patch"
